# Keil uVision project H7_Ctrl.uvprojx, settings and files
target H7_Ctrl (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7_Ctrl +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../IMU_coculate;../User_code;../User_code/CommonLibs;../User_code/CommonLibs/inc;../User_code/Device_drives;../User_code/Device_drives/inc;../User_code/Motion_Control;../User_code/Motion_Control/App/inc;../User_code/Motion_Control/Ctrl/inc;../User_code/Motion_Control/Power_control;../User_code/UI/include;../User_code/Motion_Control/App;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group IMU
    ../IMU_coculate/: BMI088driver.c BMI088Middleware.c bsp_dwt.c controller.c IMU_tasks.c imu_temp_ctrl.c kalman_filter.c MahonyAHRS.c pid.c QuaternionEKF.c user_lib.c
  group user_code
    ../User_code/: Board2Board.c Error.c State.c
    ../User_code/CommonLibs/src/: Angle_about.c CRC16.c ControlSystem.c Filter.c FricModelSIM.c Maths_about.c myQueue.c SMC.c Trigger_about.c
    ../User_code/Device_drives/src/: buzzer.c LED.c Motor_Drv.c remoter.c tfmini.c USB.c USER_CAN.c wattmeter.c
    ../User_code/Motion_Control/App/src/: chassis_control_task.cpp balance_standing.c anti_split_control.c body_speed_state.c chassis_height_control.c chassis_init.c chassis_state.c Gimbal.c gravity_comp_test.c jump_motion.c leg_retract_common.c lqr_calculate.c motor_enable.c off_ground_detect.c Self_Righting.c startup_retract_controller.cpp sit_controller.cpp spinning_motion.c stair_controller.cpp step_hit_detect.c User_State.c
    ../User_code/Motion_Control/Ctrl/src/: Gas_Spring.c Tip_Protect.c kalman_filter1.c Leg_Control.c observe_task.c ramp_generator.c user_pid.c VMC.c Wheel_End_Velocity.c Wheel_Leg_about.c Lqr_Error_Calculate.c
    ../User_code/Motion_Control/Power_control/: PowerCtrl.c RLS.c
    ../User_code/UI/source/: Crc.c Detect.c Graphics.c jlui.cpp jlui_port_freertos.c Judge.c ui_g.c ui_interface.c UI_Task.c
    ../User_code/UI/: UI_Architecture.md
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
